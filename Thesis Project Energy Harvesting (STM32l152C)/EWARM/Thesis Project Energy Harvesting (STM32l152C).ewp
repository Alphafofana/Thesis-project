# IAR project Thesis Project Energy Harvesting (STM32l152C).ewp, settings and files
configuration Thesis Project Energy Harvesting (STM32l152C) (ARM, debug)
  General.OGChipSelectEditMenu: STM32L100RC ST STM32L100RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L100xC
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Thesis Project Energy Harvesting (STM32l152C).out
  ILINK.IlinkIcfFile: stm32l100xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers
    ./: 
  group Drivers/CMSIS
    ./: 
    ../Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ./: 
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_flash_ex.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_pwr.c stm32l1xx_hal.c stm32l1xx_hal_flash.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_gpio.c stm32l1xx_hal_adc.c
  group Application
    ./: 
  group Application/User
    ./: 
    ../Src/: stm32l1xx_it.c stm32l1xx_hal_msp.c main.c
  group Application/EWARM
    ./:  startup_stm32l100xc.s
