<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Thesis Project Energy Harvesting (STM32l152C).ewp</path>
  </project>
  <batchBuild />
</workspace>
